# Keil uVision project FindMe-Test.uvprojx, settings and files
target CYBLE-012011-00_FindMeTest (ARM-ADS)
  device: CYBLE-012011-00_FindMeTest Cypress
  pack: Cypress.FindMeTest.1.0.0
  cpu: IRAM(0x20000000,0x4000) IROM(0x0,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: FindMe-Test
  AfterMake: $PExport\postbuild.bat "#L" "$L" "$P" "" ""
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
software components: CMSIS:CORE 5.3.0, Device:Startup 1.0.0
