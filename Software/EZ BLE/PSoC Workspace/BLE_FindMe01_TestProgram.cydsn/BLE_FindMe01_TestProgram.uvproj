# Keil uVision project BLE_FindMe01_TestProgram.uvproj, settings and files
target BLE_FindMe01_TestProgram (ARM-GNU)
  device: CYBLE-012011-00 Cypress
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x0-0x1FFFF) CLOCK(4800000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: BLE_FindMe01_TestProgram
  AfterMake: .\Export\postbuild.bat "#L.elf" "$L"
  group Documents
    ./: BLE_FindMe.pdf
  group Generated_Header
    Generated_Source/PSoC4/: Advertising_LED.h Advertising_LED_aliases.h Alert_LED.h Alert_LED_aliases.h BLE.h BLE_HAL_PVT.h BLE_STACK_PVT.h BLE_Stack.h BLE_StackGap.h BLE_StackGatt.h BLE_StackGattClient.h BLE_StackGattDb.h BLE_StackGattServer.h BLE_StackHostMain.h BLE_StackL2cap.h BLE_bless_isr.h BLE_eventHandler.h BLE_gatt.h BLE_ias.h CyFlash.h CyLFClk.h CyLib.h Disconnect_LED.h Disconnect_LED_aliases.h cmsis_armcc.h cmsis_compiler.h cmsis_gcc.h core_cm0.h core_cm0_psoc4.h core_cmFunc.h core_cmInstr.h cyPm.h cy_em_eeprom.h cydevice_trm.h cydevicegnu_trm.inc cydeviceiar_trm.inc cydevicerv_trm.inc cydisabledsheets.h cyfitter.h cyfitter_cfg.h cyfittergnu.inc cyfitteriar.inc cyfitterrv.inc cypins.h cytypes.h project.h
  group Generated_Source
    Generated_Source/PSoC4/: Advertising_LED.c Advertising_LED_PM.c Alert_LED.c Alert_LED_PM.c BLE.c BLE_HAL_INT.c BLE_HAL_PVT.c BLE_bless_isr.c BLE_eventHandler.c BLE_gatt.c BLE_ias.c Cm0Start.c CyBootAsmGnu.s CyFlash.c CyLFClk.c CyLib.c Disconnect_LED.c Disconnect_LED_PM.c cyPm.c cy_em_eeprom.c cyfitter_cfg.c cymetadata.c cyutils.c
  group Header
    ./: common.h cyapicallbacks.h ias.h
  group Source
    ./: ias.c main.c
